# Keil uVision project Telemetry_Science_Board2.uvprojx, settings and files
target Telemetry_Science_Board2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Telemetry_Science_Board2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xE
  c include: ../Inc;              ../Drivers/STM32L1xx_HAL_Driver/Inc;              ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;              ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: CC1200_SPI_Functions.c FRAM_Lib.c Telemetry_Packet_Protocol.c DateConversion.c SPI_FRAM.c FRAM_Tests.c Sci_Tel_SM.c main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
    ../Inc/: CC1200_reg.h CC1200_SPI_functions.h FRAM_Lib.h smartrf_CC1200.h Telemetry_Packet_Protocol.h DateConversion.h FRAM_Tests.h Sci_Tel_SM.h
    ./: Test_Commands.h
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_i2c.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
